# Repository AlexiaRat/E-Reader

File README.md:

# OpenBook E-Reader

## Despre proiect
OpenBook e un e-reader open-source facut sa fie simplu, eco-friendly si sa ofere o experienta de citit fara distractii. Am vrut sa fac un e-reader la care oricine poate contribui si pe care il poate personaliza, care sa aiba si senzori de mediu integrati.

## Diagrama bloc

## Hardware folosit

Proiectul e construit in jurul unui ESP32-C6 si are un ecran e-paper de 7.5 inch, senzori de mediu si un sistem de management al bateriei. Am incercat sa fac totul modular si cat mai open-source.

### BOM
| Componenta | Part Number | Descriere | Interfata | Datasheet | Link furnizor |
|-----------|-------------|-----------|-----------|-----------|---------------|
| Microcontroller | ESP32-C6-WROOM-1-N8 | Wi-Fi 6, BLE5, RISC-V | - | [Datasheet](https://www.espressif.com/sites/default/files/documentation/esp32-c6-wroom-1_datasheet_en.pdf) | [Mouser](https://www.mouser.com/ProductDetail/Espressif-Systems/ESP32-C6-WROOM-1-N8) |
| Ecran | WSH-13187 | Ecran e-Paper de 7.5" (800x480) | SPI | [Datasheet](https://www.waveshare.com/w/upload/7/7f/7.5inch-e-paper-specification.pdf) | [Waveshare](https://www.waveshare.com/7.5inch-e-paper.htm) |
| Senzor mediu | BME688 | Temperatura, umiditate, presiune, calitate aer | I2C | [Datasheet](https://www.bosch-sensortec.com/media/boschsensortec/downloads/datasheets/bst-bme688-ds000.pdf) | [Mouser](https://www.mouser.com/ProductDetail/Bosch-Sensortec/BME688) |
| Baterie | - | 2500mAh Li-Po cu protectie | - | - | [Mouser](https://www.mouser.com/ProductDetail/DFR0559) |
| Incarcare baterie | MCP73831 | Incarcator pentru Li-Po | - | [Datasheet](https://ww1.microchip.com/downloads/en/DeviceDoc/MCP73831-Family-Data-Sheet-DS20001984H.pdf) | [Mouser](https://www.mouser.com/ProductDetail/579-MCP73831T-2ACI-OT) |
| Masurare baterie | MAX17048G+T10 | Fuel gauge pentru baterie | I2C | [Datasheet](https://www.analog.com/media/en/technical-documentation/data-sheets/MAX17048-MAX17049.pdf) | [Mouser](https://www.mouser.com/ProductDetail/700-MAX17048G%2bT10) |
| Regulator LDO | XC6220A331MR-G | Stabilizator 3.3V | - | [Datasheet](https://www.torexsemi.com/file/xc6220/XC6220.pdf) | [Mouser](https://www.mouser.com/ProductDetail/865-XC6220A331MR-G) |
| RTC | DS3231SN | Ceas real-time cu precizie mare | I2C | [Datasheet](https://www.analog.com/media/en/technical-documentation/data-sheets/DS3231.pdf) | [Mouser](https://www.mouser.com/ProductDetail/700-DS3231SN) |
| Memorie Flash | W25Q512JVEIQ | Flash 64MB | SPI | [Datasheet](https://www.winbond.com/resource-files/W25Q512JV_DTR%20RevG%2008042021.pdf) | [Mouser](https://www.mouser.com/ProductDetail/454-W25Q512JVEIQ) |
| Conector USB-C | PFMF.050.1 | Conector USB-C | USB 2.0 | [Datasheet](https://datasheet.lcsc.com/lcsc/2008191008_SHOU-HAN-TYPE-C-16PF-067_C2988369.pdf) | [Mouser](https://www.mouser.com/ProductDetail/649-PFMF.050.1) |
| Conector SD | 112A-TAAR-R03 | Slot pentru card SD | SPI | [Datasheet](https://www.attend.com.tw/files/Datasheet/901-112A%20Series.pdf) | [Mouser](https://www.mouser.com/ProductDetail/112A-TAAR-R03) |
| Protectie ESD | USBLC6-2SC6Y | Protectie pentru USB | - | [Datasheet](https://www.st.com/resource/en/datasheet/usblc6-2.pdf) | [Mouser](https://www.mouser.com/ProductDetail/511-USBLC6-2SC6Y) |
| MOSFET | DMG2305UX-7 | MOSFET canal P | - | [Datasheet](https://www.diodes.com/assets/Datasheets/DMG2305UX.pdf) | [Mouser](https://www.mouser.com/ProductDetail/621-DMG2305UX-7) |
| Dioda Schottky | MBR0530 | Dioda de protectie | - | [Datasheet](https://www.onsemi.com/pub/Collateral/MBR0520LT1-D.PDF) | [Mouser](https://www.mouser.com/ProductDetail/833-MBR0530-TP) |
| Protectie SPI | PGB1010603MR | Protectie pentru liniile SPI | - | [Datasheet](https://www.littelfuse.com/media?resourcetype=datasheets&itemid=0eda43be-7b79-494d-8682-bcbf56e07811&filename=littelfuse-pulseguard-esd-pgb1) | [Mouser](https://www.mouser.com/ProductDetail/576-PGB1010603MR) |

## Cum functioneaza hardware-ul

### Sistemul de alimentare
Am folosit o baterie Li-Po de 2500mAh care se incarca prin USB-C folosind controlerul MCP73831. Un regulator LDO (XC6220A331MR-G) converteste tensiunea bateriei la 3.3V pentru toate componentele. Ca sa stim cat a mai ramas din baterie, am folosit un circuit MAX17048G+T10 care comunica prin I2C.

Am pus si niste MOSFET-uri DMG2305UX-7 ca sa pot folosi dispozitivul in timp ce se incarca. Bateria are protectie la supracurent, supraincarcate si temperatura, deci e safe sa o folosesti.

### Microcontroller-ul
ESP32-C6-WROOM-1-N8 e creierul operatiei si are:
- Un procesor RISC-V la 160MHz
- 512KB RAM plus 16KB RAM de low-power
- Wi-Fi 6 si Bluetooth 5 integrate
- USB 2.0
- O gramada de pini GPIO pentru conectarea chestiilor

Am pus modulul cu antena pe marginea placii si am lasat loc liber in jur ca sa aiba semnal bun. Butoanele au filtre de debounce ca sa nu faca probleme.

### Ecranul
Ecranul e-Paper de 7.5 inch e conectat prin SPI, cu cateva semnale extra:
- CS pentru selectie
- DC pentru a diferentia intre comenzi si date
- RST pentru reset
- BUSY care ne spune cand ecranul lucreaza

Am facut un circuit special pentru driver-ul ecranului, cu bobine si diode care genereaza tensiunile necesare. Am pus si un selector de tip de ecran, ca sa poata fi schimbat in viitor.

### Senzorii
BME688 masoara:
- Temperatura (cu precizie de ±1°C)
- Umiditate (±3%)
- Presiune atmosferica (±1 hPa)
- Calitatea aerului (VOC si alte gaze)

Senzorul foloseste I2C si are rezistente pull-up si condensatoare pentru filtrare. Poti folosi datele astea in timp ce citesti sau le poti salva pentru proiecte de monitorizare.

### Stocare
OpenBook are doua optiuni de stocare:
1. Un flash extern W25Q512JVEIQ de 64MB conectat prin SPI pentru firmware si setari
2. Un slot de microSD pentru carti, care suporta carduri de pana la 32GB

Ambele au protectie ESD ca sa nu se friga de la descarcari statice.

### Ceasul real-time
Am pus un DS3231SN pentru ora exacta, care are:
- Un oscilator cu cristal super precis
- Backup cu supercapacitor pentru cand se termina bateria
- Conectare I2C
- Un pin de alarma/intrerupere

### Butoanele
Sunt trei butoane fizice:
- RESET: Reporneste sistemul
- BOOT/IO: Pentru bootloader sau ca input normal
- CHANGE: Buton programabil pentru schimbat pagini, navigat in meniu, etc.

Toate au filtre RC hardware ca sa nu faca bounce.

### Conectivitate
- Port USB-C pentru incarcare si date, cu protectie ESD
- Wi-Fi 6 pentru conectare wireless si update-uri OTA
- Conector Qwiic/Stemma QT pentru module I2C
- Test pads pentru debugging

## Pinii ESP32-C6 si la ce sunt conectati

| Pin | Functie | Conectat la | Descriere |
|-----|----------|--------------|-------------|
| GPIO0 | IO0/BOOT | Buton BOOT | Control bootloader, input utilizator |
| GPIO1 | UART TX | Header debug | UART transmisie date |
| GPIO2 | SD_CS | Card SD CS | Chip select pentru SD |
| GPIO3 | UART RX | Header debug | UART receptie date |
| GPIO4 | FLASH_CS | W25Q512JVEIQ CS | Chip select pentru flash |
| GPIO5 | SPI SCK | Flash, SD, Ecran | Clock pentru SPI |
| GPIO6 | SPI MISO | Flash, SD, Ecran | Date de la periferic la microcontroller |
| GPIO7 | SPI MOSI | Flash, SD, Ecran | Date de la microcontroller la periferic |
| GPIO8 | EPD_CS | Ecran e-paper CS | Chip select pentru ecran |
| GPIO9 | EPD_DC | Ecran e-paper DC | Selectie date/comenzi |
| GPIO10 | EPD_RST | Ecran e-paper Reset | Reset pentru ecran |
| GPIO11 | EPD_BUSY | Ecran e-paper Busy | Status ecran |
| GPIO15 | IO/CHANGE | Buton CHANGE | Buton pentru utilizator |
| GPIO18 | SCL | I2C clock | Clock pentru BME688, RTC si fuel gauge |
| GPIO19 | SDA | I2C data | Date pentru BME688, RTC si fuel gauge |
| GPIO16 | TX0 | UART alternativ | TX alternativ |
| GPIO17 | RX0 | UART alternativ | RX alternativ |

## EAGLE design Hardware/PCB_OpenBook.brd

Parts:
BOOT_BUTTON: BUTTON_CUSYOMV11; MYBUTTON
C1, C2, C4_USB, C6, C8, C9, C10: 100nF; ESP32_WROVER_EAGLE-LTSPICE_C0402
C1_BAT, C1_BAT1, C1_BAT2, C2_BAT, C5_USB: 4.7uF; ESP32_WROVER_EAGLE-LTSPICE_C0402
C3: 100uF TANT; RCL_CT3528
C4: 4.7uF/25V; ESP32_WROVER_EAGLE-LTSPICE_C0402
C5: 1uF; ESP32_WROVER_EAGLE-LTSPICE_C0402
C7: 10uF; ESP32_WROVER_EAGLE-LTSPICE_C0402
C10_SUPERCAP: CPH3225A; CAPCP3225X100N
CHANGE_BUTTON: BUTTON_CUSYOMV11; MYBUTTON
CHG_LED: ADAFRUIT_LEDCHIP-LED0603; ADAFRUIT_CHIP-LED0603
C_DELAY: 100nF; ESP32_WROVER_EAGLE-LTSPICE_C0402
D1: USBLC6-2SC6Y; SOT95P280X145-6N
D2, D7: ESP32_WROVER_AVX---SD0805S020S1R0_AVX_SD0805S020S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; ESP32_WROVER_AVX---SD0805S020S1R0_AVX_SD0805S020S1R0_0
D3, D4, D5: MBR0530; SOD3716X135N
D6, D8, D9, D10, D11, D12: PGB1010603MR; DIOC1608X36N
EPD_C1, EPD_C2, EPD_C6, EPD_C7, EPD_C8, EPD_C9, EPD_C10, EPD_C11, EPD_C12: 1uF/50V; ESP32_WROVER_EAGLE-LTSPICE_C0402
EPD_C5: 0.1uF/50V; ESP32_WROVER_EAGLE-LTSPICE_C0402
IC1: BD5229G-TR; SOT95P280X125-5N
IC4: XC6220A331MR-G; SOT95P280X120-5N
J1: FH34SRJ-24S-0.5SH_99_; FH34SRJ24S05SH99
J2: SAMACSYS_PARTS_USB4110-GF-A; SAMACSYS_PARTS_USB4110GFA
J3: QWIIC_RIGHT_ANGLE; JST04_1MM_RA
J4: 112A-TAAR-R03_ATTEND; 112ATAARR03ATTEND
L1: 68uH; IND_4828-WE-TPC_WRE
MCP73831: ESP32_WROVER_SPARKFUN-IC-POWER_MCP73831; ESP32_WROVER_SPARKFUN-IC-POWER_SOT23-5
PFMF.050.1: ESP32C6_VARISTORCN1812; ESP32C6_VARISTOR_CT/CN1812
Q1, Q2: 20V/4.2A/52mΩ/1.4W; ESP32_WROVER_SPARKFUN-DISCRETESEMI_SOT23-3
Q3: SI1308EDL-T1-GE3; SOT65P210X110-3N
R1, R1-PINH, R1_PINH1, R2-PINH, R2-PINH1, R4, R5, R6, R7, R8, R9, R10: 10K; ESP32_WROVER_EAGLE-LTSPICE_C0402
R1_BAT: 200; ESP32_WROVER_EAGLE-LTSPICE_C0402
R1_PWRUSB: 100K; ESP32_WROVER_EAGLE-LTSPICE_C0402
R2: 2.2; ESP32_WROVER_EAGLE-LTSPICE_C0402
R2-USB, R2-USB1: 5k1; ESP32_WROVER_EAGLE-LTSPICE_C0402
R2_BAT: 2K; ESP32_WROVER_EAGLE-LTSPICE_C0402
R3: 0.47; ESP32_WROVER_EAGLE-LTSPICE_C0402
RESET_BUTTON: BUTTON_CUSYOMV11; MYBUTTON
R_BOOT: 10K; ESP32_WROVER_EAGLE-LTSPICE_C0402
R_CAPACITOR: 15; ESP32_WROVER_EAGLE-LTSPICE_C0402
R_CHANGE: 10K; ESP32_WROVER_EAGLE-LTSPICE_C0402
R_CL1: 10K; ESP32_WROVER_EAGLE-LTSPICE_C0402
R_RESET: 10K; ESP32_WROVER_EAGLE-LTSPICE_C0402
SENSOR2: ESP32_WROVER_BME680_BME680; ESP32_WROVER_BME680_PSON80P300X300X100-8N
SJ1: SJ
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17: TP1; TP20R
U1: W25Q512JVEIQ; SON127P600X800X80-9N
U2: ESP32-C6-WROOM-1-N8; XCVR_ESP32-C6-WROOM-1-N8
U3: DS3231SN#; SOIC127P1032X265-16N
U4: MAX17048G+T10; SON50P200X200X80-9N

Connections:
2C_PW: R1-PINH.2, R2-PINH.2
3V3: C1_BAT2.1, C3.+, C9.1, D7.1 (ANODE), IC1.2 (VDD), IC4.5 (VOUT), J3.2, J4.P4 (VDD), Q2.1 (D), R1.1, R1_PINH1.2, R2-PINH1.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R_BOOT.1, R_CHANGE.1, R_CL1.1, R_RESET.1, TP16.TP, U1.3 (!WP!(IO2)), U1.7 (!HOLD!/!RESET!(IO3)), U1.8 (VCC), U2.2 (3V3), U3.2 (VCC)
32KHZ: R2-PINH1.1, U2.9 (IO1), U3.1 (32KHZ)
DN: D1.4 (I/O2_2), J2.A7, J2.B7
DP: D1.6 (I/O1_2), J2.A6, J2.B6
EPD_3V3: C7.1, J1.16, L1.2, Q2.3 (S), TP17.TP
EPD_3V3_C: Q2.2 (G), R_CL1.2, TP13.TP, U2.18 (IO20)
EPD_BUSY: J1.9, TP9.TP, U2.26 (IO3)
EPD_CS: D6.1, J1.12, R9.1, TP10.TP, U2.11 (IO10)
EPD_DC: J1.11, TP11.TP, U2.5 (IO5)
EPD_RST: J1.10, TP12.TP, U2.21 (IO23)
FLASH_CS: D9.1, R5.1, U1.1 (!CS), U2.12 (IO11)
GDR: J1.2, Q3.1 (G), R4.1
GND: BOOT_BUTTON.1, BOOT_BUTTON.2, C1.2, C1_BAT.2, C1_BAT1.2, C1_BAT2.2, C2.2, C2_BAT.2, C3.-, C4_USB.2, C5.2, C5_USB.2, C6.2, C7.2, C8.2, C9.2, C10.2, C10_SUPERCAP.1, CHANGE_BUTTON.1, CHANGE_BUTTON.2, C_DELAY.2, D1.2 (GND), D3.2 (K), D6.2, D8.2, D9.2, D10.2, D11.2, D12.2, EPD_C1.2, EPD_C2.2, EPD_C5.2, EPD_C6.2, EPD_C7.2, EPD_C8.2, EPD_C9.2, EPD_C10.2, EPD_C11.2, EPD_C12.2, IC1.3 (GND), IC4.2 (VSS), J1.8, J1.17, J1.MP1, J1.MP2, J2.A1, J2.A12, J2.B1, J2.B12, J2.MP1, J2.MP2, J2.MP3, J2.MP4, J3.1, J4.G1 (GND_1), J4.G2 (GND_2), J4.G3 (GND_3), J4.G4 (GND_4), J4.P6 (VSS), MCP73831.2 (VSS), R1_PWRUSB.1, R2.1, R2-USB.2, R2-USB1.1, R2_BAT.1, R4.2, RESET_BUTTON.1, RESET_BUTTON.2, SENSOR2.1 (GND), SENSOR2.5 (SDO), SENSOR2.7 (GND), SJ1.1, TP4.TP, TP5.TP, U1.4 (GND), U1.9 (EXP), U2.1 (GND), U2.28 (GND), U2.29_1 (GND), U2.29_2 (GND)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
GPIO8: R1.2, U2.10 (IO8)
I2C_PW: C1.1, C2.1, SENSOR2.2 (CSB), SENSOR2.6 (VDDIO), SENSOR2.8 (VDD), U2.17 (IO19)
INT_RTC: R1_PINH1.1, TP15.TP, U2.8 (IO0), U3.3 (SQW/!INT)
IO/BOOT: BOOT_BUTTON.3, BOOT_BUTTON.4, C6.1, R_BOOT.2, U2.15 (IO9)
IO/CHANGE: C10.1, CHANGE_BUTTON.3, CHANGE_BUTTON.4, R_CHANGE.2, U2.23 (IO15)
MISO: D12.1, J4.P7 (DAT0), R8.1, TP6.TP, U1.2 (DO(IO1)), U2.27 (IO2)
MOSI: D11.1, J1.14, J4.P3 (CMD), R7.1, TP7.TP, U1.5 (DI(IO0)), U2.7 (IO7)
unnamed: J2.A5, R2-USB1.2
unnamed: J2.B5, R2-USB.1
unnamed: C1_BAT1.1, D2.2 (CATHODE), IC4.1 (VIN), IC4.3 (CE), Q1.3 (S)
unnamed: MCP73831.1 (STAT), R1_BAT.1
unnamed: CHG_LED.C, R1_BAT.2
unnamed: C4.1, D3.1 (A), D4.2 (K)
unnamed: EPD_C12.1, J1.24
unnamed: MCP73831.5 (PROG), R2_BAT.2
unnamed: EPD_C6.1, J1.18
unnamed: EPD_C7.1, J1.19
unnamed: EPD_C8.1, J1.20
unnamed: C_DELAY.1, IC1.5 (CT)
unnamed: EPD_C10.1, J1.22
unnamed: D7.2 (CATHODE), R_CAPACITOR.2
unnamed: EPD_C5.1, J1.15
unnamed: EPD_C2.1, J1.5
unnamed: EPD_C1.1, J1.4
PREVGH: D5.2 (K), EPD_C9.1, J1.21
PREVGL: D4.1 (A), EPD_C11.1, J1.23
RESE: J1.3, Q3.2 (S), R3.1
RESE': R2.2, R3.2, SJ1.2
RESET: C5.1, IC1.1 (VOUT), RESET_BUTTON.3, RESET_BUTTON.4, R_RESET.2, U2.3 (EN)
RTC_RST: U2.16 (IO18), U3.4 (!RST)
RX: TP2.TP, U2.24 (RXD0/GPIO17)
SCK: D10.1, J1.13, J4.P5 (CLK), R6.1, TP8.TP, U1.6 (CLK), U2.6 (IO6)
SCL: J3.4, R2-PINH.1, SENSOR2.4 (SCK), U2.20 (IO22), U3.16 (SCL), U4.7 (SCL)
SDA: J3.3, R1-PINH.1, SENSOR2.3 (SDI), U2.19 (IO21), U3.15 (SDA), U4.8 (SDA)
SRC: C4.2, D5.1 (A), L1.1, Q3.3 (D)
SS_SD: D8.1, J4.P2 (CD/DAT3), R10.1, U2.4 (IO4)
TX: TP1.TP, U2.25 (TXD0/GPIO16)
USB_D+: D1.1 (I/O1_1), U2.14 (IO13)
USB_D-: D1.3 (I/O2_1), U2.13 (IO12)
VBAT: C2_BAT.1, MCP73831.3 (VBAT), Q1.1 (D), TP3.TP, U4.2 (CELL), U4.3 (VDD)
VBUS: C1_BAT.1, C4_USB.1, C5_USB.1, CHG_LED.A, D1.5 (VBUS), D2.1 (ANODE), MCP73831.4 (VIN), PFMF.050.1.2, Q1.2 (G), R1_PWRUSB.2, TP14.TP
VRTC: C8.1, C10_SUPERCAP.2, R_CAPACITOR.1, U3.14 (VBAT)
VUSB: J2.A4, J2.A9, J2.B4, J2.B9, PFMF.050.1.1

Notes on the sheet:
USB C connector & ESD protection
LDO Voltage Regulator
SD Card
E-Paper Drive Circuit
Display Type Selector
Li-Po Battery Charging Controller
ESP32 C6
E-Paper Display Header
EPD Power
Environmental Sensor BME688
Voltage Supervisor + Reset & Boot / IO Button
Battery ChargeLevel
RTC Module DS3231SN
Test Pads
Qwiic / Stemma QT
SPI ESD Protection Lines
External NOR Flash 64MB
OpenBook Schematic
drawn by: Rat Alexia

Board: 2 copper layers, 170.2 x 111.2 mm, 103 parts (0 on the bottom side), 57 nets.

## Commit log

2025-04-06 Add ereader

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2024 Ultra Librarian. All rights reserved.
